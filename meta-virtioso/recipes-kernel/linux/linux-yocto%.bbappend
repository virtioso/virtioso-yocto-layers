include recipes-kernel/linux/linux-virtio.inc
