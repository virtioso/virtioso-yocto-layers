# SPDX-License-Identifier: Apache-2.0

IMAGE_INSTALL:append = " \
    kernel-module-sel4-virt \
"
