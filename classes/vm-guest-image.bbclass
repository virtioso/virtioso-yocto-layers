# Copyright 2022, Unikie
#
# SPDX-License-Identifier: Apache-2.0

IMAGE_FSTYPES += " \
    ext4.qcow2 \
"
